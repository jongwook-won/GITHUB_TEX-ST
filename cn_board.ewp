# IAR project cn_board.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x50
  General.SCCStackSize: 0x200
  General.SCRStackSize: 100
  General.GenDeviceSelectMenu: m128 ATmega128
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group (top)
    source/: allinclude.h avr_pwm.c delay.c FS_I2C_DIMMIN.c main.c timer.c timer.h twi.c uart.c uart.h
    $EW_DIR$/avr/inc/bitdefinitions/: iom128.inc
